# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; F:\training\ByOs\systemSource\ByOs\os_driver; F:\training\ByOs\systemSource\ByOs\os_kernel; F:\training\ByOs\systemSource\ByOs; F:\training\ByOs\systemSource\userSource
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_ARM#CMSIS#5.8.0}$\.iar\config\linker\ARMCM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.CCOptLevel: 3
  group ByOs
    ../../systemSource/ByOs/: os_example.c os_example.h
  group ByOs/os_driver
    ../../systemSource/ByOs/os_driver/: os_context.s os_systick.c
  group ByOs/os_kernel
    ../../systemSource/ByOs/os_kernel/: os_scheduler.c os_task.c os_tasklink.c
  group userSource
    ../../systemSource/userSource/: main.c
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device Startup
    RTE/Device/ARMCM4/: startup_ARMCM4.s system_ARMCM4.c
